# Keil uVision project Balance_car.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Balance_car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\OLED;..\HARDWARE\PWM;..\HARDWARE\ENCODER;..\HARDWARE\MOTOR;..\HARDWARE\CONTROL;..\HARDWARE\EXTI;..\HARDWARE\MPU6050;..\..\追踪小车\HARDWARE\ENCODER;..\HARDWARE\ANO_Send;..\HARDWARE\LED;..\HARDWARE\MPU6050_KALMAN;..\HARDWARE\NRF24L01
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/EXTI/: exti.c exti.h
    ../HARDWARE/MOTOR/: motor.c motor.h
    ../HARDWARE/CONTROL/: control.c control.h
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c
    ../HARDWARE/ANO_Send/: ANO_Send.c ANO_Send.h
    ../HARDWARE/LED/: LED.c LED.h
    ../HARDWARE/MPU6050_KALMAN/: kalman.c mpukalman.c
    ./: all.h
    ../HARDWARE/NRF24L01/: 24l01.c 24l01.h
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
